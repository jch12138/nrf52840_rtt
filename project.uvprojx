# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.38.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52840_XXAA, SOFTDEVICE_PRESENT, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, CONFIG_GPIO_AS_PINRESET, USE_APP_CONFIG, RT_USING_ARM_LIBC
  c misc: --reduce_paths
  c include: applications;.;libraries\cmsis\include;packages\CoreMark-latest;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;board;libraries\drivers;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;packages\nrfx-v2.1.0;packages\nrfx-v2.1.0\drivers;packages\nrfx-v2.1.0\drivers\include;packages\nrfx-v2.1.0\mdk;packages\nrfx-v2.1.0\hal;packages\nrf5x_sdk-latest\components\libraries\util;packages\nrf5x_sdk-latest\components\libraries\experimental_section_vars;packages\nrf5x_sdk-latest\components\libraries\log;packages\nrf5x_sdk-latest\components\libraries\log\src;packages\nrf5x_sdk-latest\components\libraries\strerror;packages\nrf5x_sdk-latest\components\libraries\memobj;packages\nrf5x_sdk-latest\components\libraries\balloc;packages\nrf5x_sdk-latest\components\libraries\atomic;packages\nrf5x_sdk-latest\components\libraries\atomic_flags;packages\nrf5x_sdk-latest\components\libraries\sensorsim;packages\nrf5x_sdk-latest\components\ble\ble_link_ctx_manager;packages\nrf5x_sdk-latest\components\ble\common;packages\nrf5x_sdk-latest\components\ble\ble_advertising;packages\nrf5x_sdk-latest\components\ble\nrf_ble_gatt;packages\nrf5x_sdk-latest\components\ble\nrf_ble_qwr;packages\nrf5x_sdk-latest\components\ble\ble_services\ble_lbs;packages\nrf5x_sdk-latest\components\softdevice\common;packages\nrf5x_sdk-latest\components\softdevice\s140\headers;packages\nrf5x_sdk-latest\components\softdevice\s140\headers\nrf52;packages\nrf5x_sdk-latest\integration\nrfx\legacy;packages\nrf5x_sdk-latest\components\ble\ble_services\ble_hrs;packages\nrf5x_sdk-latest\components\ble\ble_services\ble_dis;packages\nrf5x_sdk-latest\components\ble\ble_services\ble_bas
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002ae8 size 0x3d518
  group Applications
    applications/: application.c sample.c
  group coremark
    packages/CoreMark-latest/: core_state.c core_util.c core_portme.c core_main.c core_matrix.c core_list_join.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/misc/: adc.c pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_msd.c spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/src/: pipe.c waitqueue.c ringblk_buf.c workqueue.c completion.c ringbuffer.c dataqueue.c
  group Drivers
    board/: sdcard.c board.c
    libraries/drivers/: drv_gpio.c drv_adc.c drv_uart.c drv_spi.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_file.c select.c dfs.c poll.c dfs_fs.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: ffunicode.c dfs_elm.c ff.c
  group finsh
    rt-thread/components/finsh/: shell.c msh_file.c cmd.c msh.c
  group Kernel
    rt-thread/src/: irq.c mem.c idle.c device.c scheduler.c ipc.c components.c thread.c object.c clock.c timer.c kservice.c mempool.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: stdio.c mem_std.c libc.c syscalls.c
    rt-thread/components/libc/compilers/common/: unistd.c time.c stdlib.c
  group nrfx
    packages/nrfx-v2.1.0/drivers/src/: nrfx_pdm.c nrfx_usbreg.c nrfx_nfct.c nrfx_temp.c nrfx_twi_twim.c nrfx_adc.c nrfx_ppi.c nrfx_systick.c nrfx_saadc.c nrfx_dppi.c nrfx_qdec.c nrfx_twim.c nrfx_spim.c nrfx_i2s.c nrfx_pwm.c nrfx_twis.c nrfx_gpiote.c nrfx_rtc.c nrfx_wdt.c nrfx_usbd.c nrfx_qspi.c nrfx_uart.c nrfx_comp.c nrfx_lpcomp.c nrfx_rng.c nrfx_ipc.c nrfx_spi.c nrfx_twi.c nrfx_egu.c nrfx_timer.c nrfx_spis.c nrfx_uarte.c nrfx_power.c nrfx_clock.c nrfx_nvmc.c
    packages/nrfx-v2.1.0/mdk/: arm_startup_nrf52840.s system_nrf52840.c
  group SOFTDEVICE
    packages/nrf5x_sdk-latest/components/ble/common/: ble_conn_state.c ble_advdata.c ble_srv_common.c
    packages/nrf5x_sdk-latest/components/ble/ble_services/ble_bas/: ble_bas.c
    packages/nrf5x_sdk-latest/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    packages/nrf5x_sdk-latest/components/softdevice/common/: nrf_sdh.c
    packages/nrf5x_sdk-latest/rtt_adapter/: ble_conn_params_rtt.c nrf_sdh_ble_rtt.c ble_app_hrs.c
    packages/nrf5x_sdk-latest/components/libraries/util/: app_error.c app_util_platform.c app_error_weak.c
    packages/nrf5x_sdk-latest/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    packages/nrf5x_sdk-latest/components/libraries/experimental_section_vars/: nrf_section_iter.c
    packages/nrf5x_sdk-latest/components/libraries/atomic/: nrf_atomic.c
    packages/nrf5x_sdk-latest/integration/nrfx/legacy/: nrf_drv_clock.c
    packages/nrf5x_sdk-latest/components/ble/ble_services/ble_dis/: ble_dis.c
    packages/nrf5x_sdk-latest/components/libraries/strerror/: nrf_strerror.c
    packages/nrf5x_sdk-latest/components/ble/ble_advertising/: ble_advertising.c
    packages/nrf5x_sdk-latest/components/libraries/sensorsim/: sensorsim.c
    packages/nrf5x_sdk-latest/components/libraries/atomic_flags/: nrf_atflags.c
    packages/nrf5x_sdk-latest/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    packages/nrf5x_sdk-latest/components/ble/ble_services/ble_hrs/: ble_hrs.c
target softdevice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.38.0
  cpu: as above
  output: s140_nrf52_7.0.1_softdevice.hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52840_XXAA, USE_APP_CONFIG, RT_USING_ARM_LIBC  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002300 size 0x40000
  link misc: --diag_suppress 6330
